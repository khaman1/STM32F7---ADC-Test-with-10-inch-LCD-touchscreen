# Keil uVision project STM32F746I.uvprojx, settings and files
target STM32F746I Configuration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746I Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;                      ../Drivers/STM32F7xx_HAL_Driver/Inc;                      ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Include;                      ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                      ..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_uart.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_i2c_ex.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c dma.c fmc.c gpio.c main.c dma2d.c ltdc.c usart.c i2c.c adc.c
  group BSP
    ../BSP/: stm32746g_lcd.c stm32746g_sdram.c TS_I2C.c GT811.c
software components: CMSIS:CORE 4.1.0
